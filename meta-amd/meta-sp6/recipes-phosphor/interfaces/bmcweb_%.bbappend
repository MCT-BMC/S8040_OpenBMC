FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-bmcweb-Set-console-to-single-mode.patch "

