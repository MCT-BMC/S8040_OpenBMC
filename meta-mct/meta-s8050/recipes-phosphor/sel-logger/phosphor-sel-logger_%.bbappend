EXTRA_OECMAKE_append = "-DSEL_LOGGER_SEND_TO_LOGGING_SERVICE=ON"