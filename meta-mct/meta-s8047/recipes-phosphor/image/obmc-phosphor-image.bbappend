IMAGE_INSTALL += "phosphor-ipmi-ipmb"